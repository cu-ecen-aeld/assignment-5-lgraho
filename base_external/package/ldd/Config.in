## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Includes the linux device driver example modules misc-modules and scull in the kernel image.
```
